## project/demo/sharedApp/gcc/defconfig
```kconfig
CONFIG_PROJECT="sharedApp"
CONFIG_XIP=y
CONFIG_OTA=y
CONFIG_WLAN=y
# CONFIG_BLE_FEATURE is not set

CONFIG_MALLOC_TRACE=y
```
